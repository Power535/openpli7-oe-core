require dreambox-secondstage.inc

COMPATIBLE_MACHINE = "dm8000"

SRC_URI[md5sum] = "39ba8990def4ec3da75ea863d0211bc6"
SRC_URI[sha256sum] = "06271c09921ba0f6997144037206f44ff779f3c69859e9ef029f0622b1b5f665"