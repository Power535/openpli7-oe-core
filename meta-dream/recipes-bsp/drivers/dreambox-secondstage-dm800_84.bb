require dreambox-secondstage.inc

COMPATIBLE_MACHINE = "dm800"

SRC_URI[md5sum] = "7e6220db209ff3f7b7deef9d09b3eed7"
SRC_URI[sha256sum] = "f41c0dce60b9000bdcf14ba9b0cf49b96094dd1fa89635def88ad2d862b184a5"