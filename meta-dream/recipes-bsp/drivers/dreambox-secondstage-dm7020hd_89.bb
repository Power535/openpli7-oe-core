require dreambox-secondstage.inc

COMPATIBLE_MACHINE = "dm7020hd"

SRC_URI[md5sum] = "bcd4982dcc035bf28fc99f3459eaa5df"
SRC_URI[sha256sum] = "cb5a29cfba18d018a28a03ac2728bfbb1b61f152bb30013b19d1a0ac48829938"