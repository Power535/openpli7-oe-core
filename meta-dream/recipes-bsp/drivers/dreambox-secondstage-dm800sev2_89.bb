require dreambox-secondstage.inc

COMPATIBLE_MACHINE = "dm800sev2"

SRC_URI[md5sum] = "558f70b704ab693b83a25b59430b8d87"
SRC_URI[sha256sum] = "8c0d2fc0da3e3cef1de2d47f6715308b07cf031cb98128fbe8baa8eeaa130b72"