require dreambox-dvb-modules.inc

SRC_URI[modules.md5sum] = "009a6d2386b1e0bb21ecd99931f0983d"
SRC_URI[modules.sha256sum] = "691125a2c2c2d0f8a693753e03d2bf090f2dd23a287bdad98ff92e2a567eb9ac"

COMPATIBLE_MACHINE = "dm500hd"
