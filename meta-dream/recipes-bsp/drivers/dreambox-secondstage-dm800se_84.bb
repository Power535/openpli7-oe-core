require dreambox-secondstage.inc

COMPATIBLE_MACHINE = "dm800se"

SRC_URI[md5sum] = "ec18beb4321745f7ae748a19a9bad68e"
SRC_URI[sha256sum] = "6984455a9ddba39304168d66acb215c0ffa3e5e69600300f2b2841064d38d8d0"
