require dreambox-secondstage.inc

COMPATIBLE_MACHINE = "dm500hd"

SRC_URI[md5sum] = "56cd0d8250b32ef0ce8fead66da71593"
SRC_URI[sha256sum] = "754dd3f62b3b55f2e7cbfc7e94c2a5b1124e6070dc3307cf54723c3ef63b6043"